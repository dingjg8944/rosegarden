# Keil uVision project 超声波测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 超声波测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C_AND_H
  asm include: ..\C_AND_H
  group Source Group 1
    ./: STARTUP.A51
    ../C_AND_H/: BUZ_timer.c delay.c DS18B20_Drive.c DS1302_Drive.c Key_Ser.c lcd1602_Ser.c liushuideng.c main.c shumaguan.c HCSR304_drive.c
  group include
    ../C_AND_H/: all.h BUZ_timer.h delay.h DS18B20_Drive.h DS1302_Drive.h Key_Ser.h lcd1602_Ser.h liushuideng.h shumaguan.h HCSR304_drive.h
